# Keil uVision project 走马灯.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 走马灯 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    D:/电子设计大赛/单片机/big dick/: SBBBB.c System.c
    ../: STC8A8K64S4A12.h
