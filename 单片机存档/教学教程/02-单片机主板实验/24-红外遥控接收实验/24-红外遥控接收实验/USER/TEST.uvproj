# Keil uVision project TEST.uvproj, settings and files
target TEST (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: TEST +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE;..\SYSTEM;..\USER;..\HARDWARE\key;..\HARDWARE\LCD12864;..\HARDWARE\infrared;..\HARDWARE\exti;..\HARDWARE\pwm
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/: System.c
  group HARDWARE
    ../HARDWARE/key/: key.c
    ../HARDWARE/LCD12864/: lcd12864.c
    ../HARDWARE/infrared/: infrared.c
    ../HARDWARE/pwm/: pwm.c
